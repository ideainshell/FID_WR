# Keil uVision project f1_uc3_T.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f1_uc3_T +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\BSP;.\CMSIS;.\CMSIS\startup;.\STDLIB\inc;.\STDLIB\src;.\UCOSIII\APP;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III\Cfg;.\UCOSIII\uCOS-III\Ports;.\UCOSIII\uCOS-III\Source;.\USER;.\HARDWARE;.\HARDWARE\source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group APP
    ./UCOSIII/APP/: app.c
  group BSP
    ./BSP/: BSP.c led.c usart.c sys.c time.c list.c
  group HARDWARE
    ./HARDWARE/: fingerprint.c oled.c sdio_sdcard.c RTC.C
  group FATFS
    ./HARDWARE/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group STDLIB
    ./STDLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group uC/Cfg
    ./UCOSIII/uCOS-III/Cfg/: os_app_hooks.c
  group uC/LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/CPU
    ./UCOSIII/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uC/Source
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Port
    ./UCOSIII/uCOS-III/Ports/: os_cpu_c.c os_cpu_a.asm
